# Keil uVision project project_7.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: project_7
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\User\uC-CPU;..\User\uCOS-III\Ports;..\User\uCOS-III\Source;D:\keil\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group
    ../User/: app.c
  group uC/OS-III Source
    ../User/uCOS-III/Source/: os.h os_cfg.h os_cfg_app.c os_cfg_app.h os_core.c os_task.c os_time.c os_type.h os_var.c
  group uc/OS-III Ports
    ../User/uCOS-III/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC/CPU
    ../User/uC-CPU/: cpu.h cpu_a.asm
  group Doc
    ../Doc/: readm.txt
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.1
